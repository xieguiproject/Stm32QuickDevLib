# Keil uVision project Project.uvprojx, settings and files
target STM32Project (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM3210B-EVAL +hex
  c flags: Optim=2 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER,UCOS_SUPPORT,IOT_SDK_PLATFORM_UCOSIII
  c include: ..\;..\..\..\Libraries\CMSIS\CM3\CoreSupport;..\..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\..\..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\..\..\Utilities\STM32_EVAL;..\..\..\Utilities\STM32_EVAL\STM3210B_EVAL;..\..\..\Utilities\STM32_EVAL\Common;..\Bsp;..\MQTT;..\sdk\common\inc;..\sdk\platform\mico\inc;..\sdk\src\mqtt\MQTTClient-C\nettype\tls;..\sdk\public_libs\porting\micossl;..\BSP;..\APP;..\UCOSIII\uC-CPU;..\UCOSIII\uC-LIB;..\UCOSIII\uCOS-III;..\AliyunIot\auth;..\AliyunIot\mqtt;..\AliyunIot\mqtt\MQTTPacket;..\AliyunIot\platform\os\linux;..\AliyunIot\platform\ssl\mbedtls;..\AliyunIot\system;..\AliyunIot\utility;..\AliyunIot\platform\ssl
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group APP
    ../: stm32f10x_it.c
    ../APP/: APP.c Main.c
  group BSP
    ../BSP/: bsp.c Bsp_led.c Bsp_usart.c bsp_Timer.c bsp_relay.c bsp_Esp8266.c bsp_Calendar.c
  group Lib
    ../Lib/Queue/: Queue.c
  group StdPeriph_Driver
    ../../../Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_rcc.c stm32f10x_gpio.c misc.c stm32f10x_exti.c stm32f10x_usart.c stm32f10x_sdio.c stm32f10x_bkp.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dbgmcu.c stm32f10x_flash.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_tim.c stm32f10x_wwdg.c stm32f10x_rtc.c stm32f10x_spi.c stm32f10x_adc.c stm32f10x_can.c stm32f10x_dac.c stm32f10x_dma.c stm32f10x_fsmc.c stm32f10x_i2c.c
  group CMSIS
    ../../../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../: system_stm32f10x.c
  group Startup
    ../../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_cl.s startup_stm32f10x_hd.s startup_stm32f10x_ld.s startup_stm32f10x_ld_vl.s startup_stm32f10x_md.s startup_stm32f10x_md_vl.s startup_stm32f10x_xl.s startup_stm32f10x_hd_vl.s
  group Doc
    ./: readme.txt
    ../../../Doc/: ErrorLog.txt
  group uCOS-III/CPU
    ../UCOSIII/uC-CPU/: cpu_c.c cpu_core.c cpu_a.s
  group uCOS-III/LIB
    ../UCOSIII/uC-LIB/: lib_ascii.c lib_math.c lib_mem.c lib_str.c lib_mem_a.asm
  group uCOS-III/Source
    ../UCOSIII/uCOS-III/: os_app_hooks.c os_cfg_app.c os_core.c os_cpu_c.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c os_cpu_a.s
